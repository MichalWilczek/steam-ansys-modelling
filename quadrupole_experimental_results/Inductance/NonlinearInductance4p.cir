* LTSPICE Netlist of HiLumi skew quadrupole inductance
* Generated on 2019/08/1 10:00:00 at LASA Milano
* Authors: M. Prioli

************************************************************************************************************************
* The circuit has to be complemented with additional elements before the simulation (PC, crowbar, magnet resistance, ...)
************************************************************************************************************************

* Dummy inductance to pickup the current
Ldummy 0 1 1n Rser=0

* Inductance at zero current. The differential inductance is set by G1
L0 1 2 5.094721 Rser=0

G1 2 1 1l 0 table(1.000000 -0.500000,
+1.272636  -0.500000,
+1.545273  -0.500000,
+1.817909  -0.500000,
+2.090545  -0.500000,
+2.363182  -0.500000,
+2.635818  -0.500000,
+2.908454  -0.500000,
+3.181091  -0.500000,
+3.453727  -0.500000,
+3.726363  -0.500000,
+3.998999  -0.500000,
+4.271636  -0.500000,
+4.544272  -0.500000,
+4.816908  -0.500000,
+5.089545  -0.500000,
+5.362181  -0.500000,
+5.634817  -0.500000,
+5.907454  -0.500000,
+6.180090  -0.500000,
+6.452726  -0.500000,
+6.725363  -0.500000,
+6.997999  -0.500000,
+7.270635  -0.500000,
+7.543272  -0.500000,
+7.815908  -0.500000,
+8.088544  -0.500000,
+8.361181  -0.500000,
+8.633817  -0.500000,
+8.906453  -0.500000,
+9.179090  -0.500000,
+9.451726  -0.500000,
+9.724362  -0.500000,
+9.996998  -0.500000,
+10.269635 -0.500000,
+10.542271 -0.500000,
+10.814907 -0.500000,
+11.087544 -0.500000,
+11.360180 -0.500000,
+11.632816 -0.500000,
+11.905453 -0.500000,
+12.178089 -0.500000,
+12.450725 -0.500000,
+12.723362 -0.500000,
+12.995998 -0.500000,
+13.268634 -0.500000,
+13.541271 -0.500000,
+13.813907 -0.500000,
+14.086543 -0.500000,
+14.359180 -0.500000,
+14.631816 -0.500000,
+14.904452 -0.500000,
+15.177089 -0.500000,
+15.449725 -0.500000,
+15.722361 -0.500000,
+15.994997 -0.500000,
+16.267634 -0.499999,
+16.540270 -0.499999,
+16.812906 -0.499999,
+17.085543 -0.500001,
+17.358179 -0.500003,
+17.630815 -0.500005,
+17.903452 -0.500002,
+18.176088 -0.499994,
+18.448724 -0.499985,
+18.721361 -0.499984,
+18.993997 -0.499999,
+19.266633 -0.500032,
+19.539270 -0.500057,
+19.811906 -0.500046,
+20.084542 -0.499969,
+20.357179 -0.499820,
+20.629815 -0.499633,
+20.902451 -0.499440,
+21.175088 -0.499274,
+21.447724 -0.499167,
+21.720360 -0.499149,
+21.992996 -0.499249,
+22.265633 -0.499495,
+22.538269 -0.499915,
+22.810905 -0.500533,
+23.083542 -0.501376,
+23.356178 -0.502467,
+23.628814 -0.503829,
+23.901451 -0.505487,
+24.174087 -0.507460,
+24.446723 -0.509770,
+24.719360 -0.512438,
+24.991996 -0.515483,
+25.264632 -0.518924,
+25.537269 -0.522780,
+25.809905 -0.527068,
+26.082541 -0.531807,
+26.355178 -0.537011,
+26.627814 -0.542699,
+26.900450 -0.548885,
+27.173087 -0.555585,
+27.445723 -0.562813,
+27.718359 -0.570584,
+27.990995 -0.578913,
+28.263632 -0.587811,
+28.536268 -0.597293,
+28.808904 -0.607372,
+29.081541 -0.618059,
+29.354177 -0.629367,
+29.626813 -0.641307,
+29.899450 -0.653891,
+30.172086 -0.667131,
+30.444722 -0.681036,
+30.717359 -0.695617,
+30.989995 -0.710885,
+31.262631 -0.726849,
+31.535268 -0.743520,
+31.807904 -0.760906,
+32.080540 -0.779017,
+32.353177 -0.797861,
+32.625813 -0.817449,
+32.898449 -0.837787,
+33.171086 -0.858885,
+33.443722 -0.880750,
+33.716358 -0.903390,
+33.988994 -0.926814,
+34.261631 -0.951029,
+34.534267 -0.976041,
+34.806903 -1.001859,
+35.079540 -1.028489,
+35.352176 -1.055938,
+35.624812 -1.084213,
+35.897449 -1.113320,
+36.170085 -1.143266,
+36.442721 -1.174057,
+36.715358 -1.205701,
+36.987994 -1.238211,
+37.260630 -1.271601,
+37.533267 -1.305884,
+37.805903 -1.341073,
+38.078539 -1.377182,
+38.351176 -1.414221,
+38.623812 -1.452204,
+38.896448 -1.491142,
+39.169085 -1.531048,
+39.441721 -1.571931,
+39.714357 -1.613805,
+39.986993 -1.656679,
+40.259630 -1.700567,
+40.532266 -1.745497,
+40.804902 -1.791503,
+41.077539 -1.838620,
+41.350175 -1.886881,
+41.622811 -1.936318,
+41.895448 -1.986963,
+42.168084 -2.038849,
+42.440720 -2.092004,
+42.713357 -2.146461,
+42.985993 -2.202248,
+43.258629 -2.259394,
+43.531266 -2.317928,
+43.803902 -2.377878,
+44.076538 -2.439271,
+44.349175 -2.502134,
+44.621811 -2.566493,
+44.894447 -2.632376,
+45.167084 -2.699806,
+45.439720 -2.768809,
+45.712356 -2.839410,
+45.984992 -2.911632,
+46.257629 -2.985500,
+46.530265 -3.061036,
+46.802901 -3.138265,
+47.075538 -3.217207,
+47.348174 -3.297885,
+47.620810 -3.380321,
+47.893447 -3.464536,
+48.166083 -3.550552,
+48.438719 -3.638388,
+48.711356 -3.728065,
+48.983992 -3.819603,
+49.256628 -3.913021,
+49.529265 -4.008312,
+49.801901 -4.105438,
+50.074537 -4.204362,
+50.347174 -4.305046,
+50.619810 -4.407453,
+50.892446 -4.511545,
+51.165083 -4.617288,
+51.437719 -4.724646,
+51.710355 -4.833584,
+51.982991 -4.944067,
+52.255628 -5.056063,
+52.528264 -5.169538,
+52.800900 -5.284459,
+53.073537 -5.400794,
+53.346173 -5.518512,
+53.618809 -5.637581,
+53.891446 -5.757970,
+54.164082 -5.879650,
+54.436718 -6.002591,
+54.709355 -6.126763,
+54.981991 -6.252131,
+55.254627 -6.378655,
+55.527264 -6.506295,
+55.799900 -6.635010,
+56.072536 -6.764761,
+56.345173 -6.895509,
+56.617809 -7.027216,
+56.890445 -7.159844,
+57.163082 -7.293356,
+57.435718 -7.427715,
+57.708354 -7.562886,
+57.980990 -7.698832,
+58.253627 -7.835518,
+58.526263 -7.972910,
+58.798899 -8.110973,
+59.071536 -8.249675,
+59.344172 -8.388981,
+59.616808 -8.528859,
+59.889445 -8.669277,
+60.162081 -8.810202,
+60.434717 -8.951604,
+60.707354 -9.093451,
+60.979990 -9.235713,
+61.252626 -9.378360,
+61.525263 -9.521361,
+61.797899 -9.664688,
+62.070535 -9.808312,
+62.343172 -9.952225,
+62.615808 -10.096425,
+62.888444 -10.240913,
+63.161081 -10.385689,
+63.433717 -10.530753,
+63.706353 -10.676105,
+63.978989 -10.821744,
+64.251626 -10.967672,
+64.524262 -11.113887,
+64.796898 -11.260390,
+65.069535 -11.407182,
+65.342171 -11.554261,
+65.614807 -11.701628,
+65.887444 -11.849284,
+66.160080 -11.997227,
+66.432716 -12.145459,
+66.705353 -12.293978,
+66.977989 -12.442786,
+67.250625 -12.591882,
+67.523262 -12.741266,
+67.795898 -12.890939,
+68.068534 -13.040899,
+68.341171 -13.191148,
+68.613807 -13.341683,
+68.886443 -13.492502,
+69.159080 -13.643599,
+69.431716 -13.794970,
+69.704352 -13.946613,
+69.976988 -14.098523,
+70.249625 -14.250696,
+70.522261 -14.403128,
+70.794897 -14.555816,
+71.067534 -14.708756,
+71.340170 -14.861944,
+71.612806 -15.015377,
+71.885443 -15.169051,
+72.158079 -15.322962,
+72.430715 -15.477108,
+72.703352 -15.631484,
+72.975988 -15.786087,
+73.248624 -15.940915,
+73.521261 -16.095966,
+73.793897 -16.251238,
+74.066533 -16.406730,
+74.339170 -16.562439,
+74.611806 -16.718363,
+74.884442 -16.874502,
+75.157079 -17.030853,
+75.429715 -17.187414,
+75.702351 -17.344184,
+75.974987 -17.501162,
+76.247624 -17.658345,
+76.520260 -17.815731,
+76.792896 -17.973320,
+77.065533 -18.131110,
+77.338169 -18.289099,
+77.610805 -18.447285,
+77.883442 -18.605667,
+78.156078 -18.764244,
+78.428714 -18.923013,
+78.701351 -19.081974,
+78.973987 -19.241125,
+79.246623 -19.400464,
+79.519260 -19.559990,
+79.791896 -19.719701,
+80.064532 -19.879597,
+80.337169 -20.039676,
+80.609805 -20.199935,
+80.882441 -20.360375,
+81.155078 -20.520993,
+81.427714 -20.681788,
+81.700350 -20.842759,
+81.972986 -21.003904,
+82.245623 -21.165223,
+82.518259 -21.326714,
+82.790895 -21.488375,
+83.063532 -21.650207,
+83.336168 -21.812208,
+83.608804 -21.974377,
+83.881441 -22.136713,
+84.154077 -22.299214,
+84.426713 -22.461881,
+84.699350 -22.624711,
+84.971986 -22.787704,
+85.244622 -22.950860,
+85.517259 -23.114176,
+85.789895 -23.277652,
+86.062531 -23.441287,
+86.335168 -23.605080,
+86.607804 -23.769031,
+86.880440 -23.933137,
+87.153077 -24.097399,
+87.425713 -24.261816,
+87.698349 -24.426386,
+87.970985 -24.591109,
+88.243622 -24.755983,
+88.516258 -24.921008,
+88.788894 -25.086184,
+89.061531 -25.251508,
+89.334167 -25.416981,
+89.606803 -25.582601,
+89.879440 -25.748368,
+90.152076 -25.914281,
+90.424712 -26.080339,
+90.697349 -26.246541,
+90.969985 -26.412886,
+91.242621 -26.579374,
+91.515258 -26.746004,
+91.787894 -26.912775,
+92.060530 -27.079687,
+92.333167 -27.246740,
+92.605803 -27.413932,
+92.878439 -27.581264,
+93.151076 -27.748734,
+93.423712 -27.916342,
+93.696348 -28.084088,
+93.968984 -28.251971,
+94.241621 -28.419990,
+94.514257 -28.588145,
+94.786893 -28.756436,
+95.059530 -28.924862,
+95.332166 -29.093422,
+95.604802 -29.262116,
+95.877439 -29.430944,
+96.150075 -29.599905,
+96.422711 -29.768998,
+96.695348 -29.938223,
+96.967984 -30.107579,
+97.240620 -30.277067,
+97.513257 -30.446685,
+97.785893 -30.616433,
+98.058529 -30.786311,
+98.331166 -30.956318,
+98.603802 -31.126454,
+98.876438 -31.296717,
+99.149075 -31.467109,
+99.421711 -31.637628,
+99.694347 -31.808274,
+99.966983 -31.979046,
+100.239620 -32.149944,
+100.512256 -32.320968,
+100.784892 -32.492117,
+101.057529 -32.663390,
+101.330165 -32.834787,
+101.602801 -33.006307,
+101.875438 -33.177949,
+102.148074 -33.349714,
+102.420710 -33.521600,
+102.693347 -33.693607,
+102.965983 -33.865735,
+103.238619 -34.037982,
+103.511256 -34.210349,
+103.783892 -34.382834,
+104.056528 -34.555438,
+104.329165 -34.728160,
+104.601801 -34.900999,
+104.874437 -35.073954,
+105.147074 -35.247026,
+105.419710 -35.420213,
+105.692346 -35.593516,
+105.964982 -35.766933,
+106.237619 -35.940464,
+106.510255 -36.114109,
+106.782891 -36.287868,
+107.055528 -36.461739,
+107.328164 -36.635722,
+107.600800 -36.809817,
+107.873437 -36.984023,
+108.146073 -37.158340,
+108.418709 -37.332768,
+108.691346 -37.507305,
+108.963982 -37.681951,
+109.236618 -37.856707,
+109.509255 -38.031571,
+109.781891 -38.206543,
+110.054527 -38.381623,
+110.327164 -38.556810,
+110.599800 -38.732103,
+110.872436 -38.907502,
+111.145073 -39.083007,
+111.417709 -39.258617,
+111.690345 -39.434331,
+111.962981 -39.610150,
+112.235618 -39.786073,
+112.508254 -39.962099,
+112.780890 -40.138227,
+113.053527 -40.314458,
+113.326163 -40.490791,
+113.598799 -40.667226,
+113.871436 -40.843762,
+114.144072 -41.020398,
+114.416708 -41.197134,
+114.689345 -41.373970,
+114.961981 -41.550905,
+115.234617 -41.727940,
+115.507254 -41.905073,
+115.779890 -42.082303,
+116.052526 -42.259632,
+116.325163 -42.437057,
+116.597799 -42.614580,
+116.870435 -42.792199,
+117.143072 -42.969914,
+117.415708 -43.147724,
+117.688344 -43.325630,
+117.960980 -43.503630,
+118.233617 -43.681725,
+118.506253 -43.859914,
+118.778889 -44.038197,
+119.051526 -44.216574,
+119.324162 -44.395045,
+119.596798 -44.573609,
+119.869435 -44.752268,
+120.142071 -44.931020,
+120.414707 -45.109866,
+120.687344 -45.288806,
+120.959980 -45.467840,
+121.232616 -45.646967,
+121.505253 -45.826188,
+121.777889 -46.005503,
+122.050525 -46.184912,
+122.323162 -46.364414,
+122.595798 -46.544010,
+122.868434 -46.723700,
+123.141071 -46.903483,
+123.413707 -47.083360,
+123.686343 -47.263330,
+123.958979 -47.443395,
+124.231616 -47.623552,
+124.504252 -47.803804,
+124.776888 -47.984149,
+125.049525 -48.164587,
+125.322161 -48.345119,
+125.594797 -48.525745,
+125.867434 -48.706464,
+126.140070 -48.887277,
+126.412706 -49.068183,
+126.685343 -49.249182,
+126.957979 -49.430275,
+127.230615 -49.611461,
+127.503252 -49.792741,
+127.775888 -49.974114,
+128.048524 -50.155581,
+128.321161 -50.337140,
+128.593797 -50.518792,
+128.866433 -50.700536,
+129.139070 -50.882372,
+129.411706 -51.064301,
+129.684342 -51.246322,
+129.956978 -51.428434,
+130.229615 -51.610637,
+130.502251 -51.792932,
+130.774887 -51.975318,
+131.047524 -52.157794,
+131.320160 -52.340361,
+131.592796 -52.523019,
+131.865433 -52.705767,
+132.138069 -52.888604,
+132.410705 -53.071532,
+132.683342 -53.254549,
+132.955978 -53.437656,
+133.228614 -53.620852,
+133.501251 -53.804137,
+133.773887 -53.987510,
+134.046523 -54.170973,
+134.319160 -54.354524,
+134.591796 -54.538163,
+134.864432 -54.721890,
+135.137069 -54.905705,
+135.409705 -55.089608,
+135.682341 -55.273599,
+135.954977 -55.457677,
+136.227614 -55.641842,
+136.500250 -55.826094,
+136.772886 -56.010433,
+137.045523 -56.194857,
+137.318159 -56.379366,
+137.590795 -56.563959,
+137.863432 -56.748635,
+138.136068 -56.933393,
+138.408704 -57.118231,
+138.681341 -57.303148,
+138.953977 -57.488145,
+139.226613 -57.673219,
+139.499250 -57.858370,
+139.771886 -58.043596,
+140.044522 -58.228898,
+140.317159 -58.414273,
+140.589795 -58.599721,
+140.862431 -58.785240,
+141.135068 -58.970831,
+141.407704 -59.156492,
+141.680340 -59.342221,
+141.952976 -59.528019,
+142.225613 -59.713884,
+142.498249 -59.899815,
+142.770885 -60.085812,
+143.043522 -60.271873,
+143.316158 -60.457997,
+143.588794 -60.644184,
+143.861431 -60.830432,
+144.134067 -61.016742,
+144.406703 -61.203111,
+144.679340 -61.389539,
+144.951976 -61.576026,
+145.224612 -61.762570,
+145.497249 -61.949170,
+145.769885 -62.135825,
+146.042521 -62.322536,
+146.315158 -62.509301,
+146.587794 -62.696120,
+146.860430 -62.882992,
+147.133067 -63.069918,
+147.405703 -63.256895,
+147.678339 -63.443925,
+147.950975 -63.631007,
+148.223612 -63.818139,
+148.496248 -64.005322,
+148.768884 -64.192556,
+149.041521 -64.379839,
+149.314157 -64.567171,
+149.586793 -64.754552,
+149.859430 -64.941981,
+150.132066 -65.129458,
+150.404702 -65.316983,
+150.677339 -65.504554,
+150.949975 -65.692172,
+151.222611 -65.879836,
+151.495248 -66.067546,
+151.767884 -66.255301,
+152.040520 -66.443101,
+152.313157 -66.630945,
+152.585793 -66.818833,
+152.858429 -67.006764,
+153.131066 -67.194739,
+153.403702 -67.382756,
+153.676338 -67.570815,
+153.948974 -67.758916,
+154.221611 -67.947059,
+154.494247 -68.135242,
+154.766883 -68.323466,
+155.039520 -68.511730,
+155.312156 -68.700034,
+155.584792 -68.888378,
+155.857429 -69.076762,
+156.130065 -69.265184,
+156.402701 -69.453646,
+156.675338 -69.642147,
+156.947974 -69.830686,
+157.220610 -70.019264,
+157.493247 -70.207879,
+157.765883 -70.396533,
+158.038519 -70.585225,
+158.311156 -70.773954,
+158.583792 -70.962720,
+158.856428 -71.151524,
+159.129065 -71.340364,
+159.401701 -71.529242,
+159.674337 -71.718155,
+159.946973 -71.907105,
+160.219610 -72.096091,
+160.492246 -72.285113,
+160.764882 -72.474171,
+161.037519 -72.663264,
+161.310155 -72.852392,
+161.582791 -73.041556,
+161.855428 -73.230754,
+162.128064 -73.419987,
+162.400700 -73.609255,
+162.673337 -73.798557,
+162.945973 -73.987892,
+163.218609 -74.177262,
+163.491246 -74.366666,
+163.763882 -74.556103,
+164.036518 -74.745573,
+164.309155 -74.935076,
+164.581791 -75.124613,
+164.854427 -75.314182,
+165.127064 -75.503784,
+165.399700 -75.693418,
+165.672336 -75.883085,
+165.944972 -76.072785,
+166.217609 -76.262516,
+166.490245 -76.452279,
+166.762881 -76.642074,
+167.035518 -76.831900,
+167.308154 -77.021758,
+167.580790 -77.211648,
+167.853427 -77.401568,
+168.126063 -77.591520,
+168.398699 -77.781502,
+168.671336 -77.971516,
+168.943972 -78.161559,
+169.216608 -78.351634,
+169.489245 -78.541738,
+169.761881 -78.731873,
+170.034517 -78.922038,
+170.307154 -79.112233,
+170.579790 -79.302457,
+170.852426 -79.492712,
+171.125063 -79.682995,
+171.397699 -79.873308,
+171.670335 -80.063650,
+171.942971 -80.254022,
+172.215608 -80.444422,
+172.488244 -80.634851,
+172.760880 -80.825309,
+173.033517 -81.015795,
+173.306153 -81.206309,
+173.578789 -81.396852,
+173.851426 -81.587423,
+174.124062 -81.778023,
+174.396698 -81.968650,
+174.669335 -82.159305,
+174.941971 -82.349987,
+175.214607 -82.540698,
+175.487244 -82.731435,
+175.759880 -82.922200,
+176.032516 -83.112993,
+176.305153 -83.303812,
+176.577789 -83.494659,
+176.850425 -83.685533,
+177.123062 -83.876433,
+177.395698 -84.067360,
+177.668334 -84.258314,
+177.940970 -84.449294,
+178.213607 -84.640301,
+178.486243 -84.831333,
+178.758879 -85.022393,
+179.031516 -85.213478,
+179.304152 -85.404589,
+179.576788 -85.595726,
+179.849425 -85.786889,
+180.122061 -85.978077,
+180.394697 -86.169291,
+180.667334 -86.360530,
+180.939970 -86.551795,
+181.212606 -86.743085,
+181.485243 -86.934400,
+181.757879 -87.125741,
+182.030515 -87.317106,
+182.303152 -87.508496,
+182.575788 -87.699910,
+182.848424 -87.891350,
+183.121061 -88.082814,
+183.393697 -88.274302,
+183.666333 -88.465814,
+183.938969 -88.657351,
+184.211606 -88.848912,
+184.484242 -89.040496,
+184.756878 -89.232105,
+185.029515 -89.423737,
+185.302151 -89.615393,
+185.574787 -89.807072,
+185.847424 -89.998775,
+186.120060 -90.190501,
+186.392696 -90.382250,
+186.665333 -90.574023,
+186.937969 -90.765818,
+187.210605 -90.957636,
+187.483242 -91.149477,
+187.755878 -91.341341,
+188.028514 -91.533227,
+188.301151 -91.725135,
+188.573787 -91.917066,
+188.846423 -92.109019,
+189.119060 -92.300995,
+189.391696 -92.492992,
+189.664332 -92.685011,
+189.936968 -92.877053,
+190.209605 -93.069115,
+190.482241 -93.261200,
+190.754877 -93.453306,
+191.027514 -93.645434,
+191.300150 -93.837582,
+191.572786 -94.029752,
+191.845423 -94.221944,
+192.118059 -94.414156,
+192.390695 -94.606389,
+192.663332 -94.798643,
+192.935968 -94.990918,
+193.208604 -95.183213,
+193.481241 -95.375529,
+193.753877 -95.567866,
+194.026513 -95.760223,
+194.299150 -95.952600,
+194.571786 -96.144997,
+194.844422 -96.337415,
+195.117059 -96.529852,
+195.389695 -96.722309,
+195.662331 -96.914787,
+195.934967 -97.107283,
+196.207604 -97.299800,
+196.480240 -97.492336,
+196.752876 -97.684891,
+197.025513 -97.877466,
+197.298149 -98.070060,
+197.570785 -98.262674,
+197.843422 -98.455307,
+198.116058 -98.647959,
+198.388694 -98.840630,
+198.661331 -99.033321,
+198.933967 -99.226031,
+199.206603 -99.418759,
+199.479240 -99.611507,
+199.751876 -99.804274,
+200.024512 -99.997060,
+200.297149 -100.189866,
+200.569785 -100.382690,
+200.842421 -100.575533,
+201.115058 -100.768395,
+201.387694 -100.961275,
+201.660330 -101.154175,
+201.932966 -101.347093,
+202.205603 -101.540031,
+202.478239 -101.732987,
+202.750875 -101.925962,
+203.023512 -102.118955,
+203.296148 -102.311967,
+203.568784 -102.504998,
+203.841421 -102.698047,
+204.114057 -102.891115,
+204.386693 -103.084202,
+204.659330 -103.277307,
+204.931966 -103.470431,
+205.204602 -103.663573,
+205.477239 -103.856733,
+205.749875 -104.049912,
+206.022511 -104.243109,
+206.295148 -104.436325,
+206.567784 -104.629559,
+206.840420 -104.822811,
+207.113057 -105.016082,
+207.385693 -105.209370,
+207.658329 -105.402677,
+207.930965 -105.596002,
+208.203602 -105.789346,
+208.476238 -105.982707,
+208.748874 -106.176086,
+209.021511 -106.369484,
+209.294147 -106.562900,
+209.566783 -106.756333,
+209.839420 -106.949785,
+210.112056 -107.143254,
+210.384692 -107.336742,
+210.657329 -107.530247,
+210.929965 -107.723771,
+211.202601 -107.917312,
+211.475238 -108.110871,
+211.747874 -108.304447,
+212.020510 -108.498042,
+212.293147 -108.691654,
+212.565783 -108.885284,
+212.838419 -109.078932,
+213.111056 -109.272597,
+213.383692 -109.466280,
+213.656328 -109.659981,
+213.928964 -109.853699,
+214.201601 -110.047435,
+214.474237 -110.241188,
+214.746873 -110.434959,
+215.019510 -110.628747,
+215.292146 -110.822553,
+215.564782 -111.016376,
+215.837419 -111.210216,
+216.110055 -111.404074,
+216.382691 -111.597950,
+216.655328 -111.791842,
+216.927964 -111.985752,
+217.200600 -112.179680,
+217.473237 -112.373624,
+217.745873 -112.567586,
+218.018509 -112.761565,
+218.291146 -112.955561,
+218.563782 -113.149574,
+218.836418 -113.343605,
+219.109055 -113.537652,
+219.381691 -113.731717,
+219.654327 -113.925798,
+219.926963 -114.119897,
+220.199600 -114.314012,
+220.472236 -114.508144,
+220.744872 -114.702293,
+221.017509 -114.896458,
+221.290145 -115.090641,
+221.562781 -115.284839,
+221.835418 -115.479055,
+222.108054 -115.673286,
+222.380690 -115.867535,
+222.653327 -116.061799,
+222.925963 -116.256080,
+223.198599 -116.450377,
+223.471236 -116.644691,
+223.743872 -116.839020,
+224.016508 -117.033366,
+224.289145 -117.227728,
+224.561781 -117.422105,
+224.834417 -117.616499,
+225.107054 -117.810909,
+225.379690 -118.005334,
+225.652326 -118.199776,
+225.924962 -118.394233,
+226.197599 -118.588706,
+226.470235 -118.783194,
+226.742871 -118.977699,
+227.015508 -119.172218,
+227.288144 -119.366754,
+227.560780 -119.561304,
+227.833417 -119.755870,
+228.106053 -119.950452,
+228.378689 -120.145049,
+228.651326 -120.339661,
+228.923962 -120.534289,
+229.196598 -120.728931,
+229.469235 -120.923589,
+229.741871 -121.118262,
+230.014507 -121.312950,
+230.287144 -121.507653,
+230.559780 -121.702371,
+230.832416 -121.897103,
+231.105053 -122.091851,
+231.377689 -122.286613,
+231.650325 -122.481391,
+231.922961 -122.676183,
+232.195598 -122.870989,
+232.468234 -123.065811,
+232.740870 -123.260646,
+233.013507 -123.455497,
+233.286143 -123.650362,
+233.558779 -123.845241,
+233.831416 -124.040135,
+234.104052 -124.235043,
+234.376688 -124.429966,
+234.649325 -124.624902,
+234.921961 -124.819853,
+235.194597 -125.014819,
+235.467234 -125.209798,
+235.739870 -125.404791,
+236.012506 -125.599799,
+236.285143 -125.794820,
+236.557779 -125.989856,
+236.830415 -126.184905,
+237.103052 -126.379968,
+237.375688 -126.575045,
+237.648324 -126.770136,
+237.920960 -126.965241,
+238.193597 -127.160359,
+238.466233 -127.355491,
+238.738869 -127.550637,
+239.011506 -127.745796,
+239.284142 -127.940969,
+239.556778 -128.136156,
+239.829415 -128.331355,
+240.102051 -128.526569,
+240.374687 -128.721795,
+240.647324 -128.917035,
+240.919960 -129.112289,
+241.192596 -129.307555,
+241.465233 -129.502835,
+241.737869 -129.698128,
+242.010505 -129.893434,
+242.283142 -130.088753,
+242.555778 -130.284085,
+242.828414 -130.479430,
+243.101051 -130.674788,
+243.373687 -130.870160,
+243.646323 -131.065544,
+243.918959 -131.260941,
+244.191596 -131.456350,
+244.464232 -131.651773,
+244.736868 -131.847208,
+245.009505 -132.042656,
+245.282141 -132.238117,
+245.554777 -132.433590,
+245.827414 -132.629076,
+246.100050 -132.824574,
+246.372686 -133.020085,
+246.645323 -133.215608,
+246.917959 -133.411144,
+247.190595 -133.606692,
+247.463232 -133.802253,
+247.735868 -133.997826,
+248.008504 -134.193411,
+248.281141 -134.389008,
+248.553777 -134.584618,
+248.826413 -134.780240,
+249.099050 -134.975874,
+249.371686 -135.171520,
+249.644322 -135.367178,
+249.916958 -135.562848,
+250.189595 -135.758530,
+250.462231 -135.954224,
+250.734867 -136.149930,
+251.007504 -136.345648,
+251.280140 -136.541378,
+251.552776 -136.737119,
+251.825413 -136.932873,
+252.098049 -137.128638,
+252.370685 -137.324414,
+252.643322 -137.520203,
+252.915958 -137.716003,
+253.188594 -137.911814,
+253.461231 -138.107638,
+253.733867 -138.303472,
+254.006503 -138.499319,
+254.279140 -138.695176,
+254.551776 -138.891045,
+254.824412 -139.086926,
+255.097049 -139.282818,
+255.369685 -139.478721,
+255.642321 -139.674635,
+255.914957 -139.870561,
+256.187594 -140.066498,
+256.460230 -140.262446,
+256.732866 -140.458405,
+257.005503 -140.654375,
+257.278139 -140.850357,
+257.550775 -141.046349,
+257.823412 -141.242353,
+258.096048 -141.438367,
+258.368684 -141.634393,
+258.641321 -141.830429,
+258.913957 -142.026476,
+259.186593 -142.222534,
+259.459230 -142.418603,
+259.731866 -142.614683,
+260.004502 -142.810773,
+260.277139 -143.006874,
+260.549775 -143.202986,
+260.822411 -143.399109,
+261.095048 -143.595242,
+261.367684 -143.791386,
+261.640320 -143.987540,
+261.912956 -144.183705,
+262.185593 -144.379880,
+262.458229 -144.576066,
+262.730865 -144.772262,
+263.003502 -144.968468,
+263.276138 -145.164685,
+263.548774 -145.360913,
+263.821411 -145.557150,
+264.094047 -145.753398,
+264.366683 -145.949656,
+264.639320 -146.145925,
+264.911956 -146.342203,
+265.184592 -146.538492,
+265.457229 -146.734790,
+265.729865 -146.931099,
+266.002501 -147.127418,
+266.275138 -147.323747,
+266.547774 -147.520086,
+266.820410 -147.716435,
+267.093047 -147.912794,
+267.365683 -148.109163,
+267.638319 -148.305542,
+267.910955 -148.501930,
+268.183592 -148.698328,
+268.456228 -148.894737,
+268.728864 -149.091155,
+269.001501 -149.287582,
+269.274137 -149.484020,
+269.546773 -149.680467,
+269.819410 -149.876923,
+270.092046 -150.073390,
+270.364682 -150.269865,
+270.637319 -150.466351,
+270.909955 -150.662846,
+271.182591 -150.859350,
+271.455228 -151.055864,
+271.727864 -151.252388,
+272.000500 -151.448921,
+272.273137 -151.645463,
+272.545773 -151.842014,
+272.818409 -152.038575,
+273.091046 -152.235145,
+273.363682 -152.431725,
+273.636318 -152.628314,
+273.908954 -152.824912,
+274.181591 -153.021519,
+274.454227 -153.218135,
+274.726863 -153.414761,
+274.999500 -153.611396,
+275.272136 -153.808040,
+275.544772 -154.004693,
+275.817409 -154.201356,
+276.090045 -154.398027,
+276.362681 -154.594708,
+276.635318 -154.791398,
+276.907954 -154.988097,
+277.180590 -155.184804,
+277.453227 -155.381522,
+277.725863 -155.578248,
+277.998499 -155.774983,
+278.271136 -155.971727,
+278.543772 -156.168480,
+278.816408 -156.365242,
+279.089045 -156.562014,
+279.361681 -156.758794,
+279.634317 -156.955583,
+279.906953 -157.152381,
+280.179590 -157.349188,
+280.452226 -157.546004,
+280.724862 -157.742829,
+280.997499 -157.939663,
+281.270135 -158.136505,
+281.542771 -158.333357,
+281.815408 -158.530217,
+282.088044 -158.727086,
+282.360680 -158.923964,
+282.633317 -159.120851,
+282.905953 -159.317747,
+283.178589 -159.514652,
+283.451226 -159.711565,
+283.723862 -159.908487,
+283.996498 -160.105418,
+284.269135 -160.302357,
+284.541771 -160.499306,
+284.814407 -160.696263,
+285.087044 -160.893228,
+285.359680 -161.090203,
+285.632316 -161.287186,
+285.904952 -161.484178,
+286.177589 -161.681178,
+286.450225 -161.878187,
+286.722861 -162.075205,
+286.995498 -162.272231,
+287.268134 -162.469266,
+287.540770 -162.666310,
+287.813407 -162.863362,
+288.086043 -163.060422,
+288.358679 -163.257492,
+288.631316 -163.454570,
+288.903952 -163.651656,
+289.176588 -163.848751,
+289.449225 -164.045854,
+289.721861 -164.242966,
+289.994497 -164.440086,
+290.267134 -164.637215,
+290.539770 -164.834353,
+290.812406 -165.031498,
+291.085043 -165.228653,
+291.357679 -165.425815,
+291.630315 -165.622986,
+291.902951 -165.820166,
+292.175588 -166.017354,
+292.448224 -166.214550,
+292.720860 -166.411754,
+292.993497 -166.608967,
+293.266133 -166.806189,
+293.538769 -167.003418,
+293.811406 -167.200656,
+294.084042 -167.397903,
+294.356678 -167.595157,
+294.629315 -167.792420,
+294.901951 -167.989691,
+295.174587 -168.186971,
+295.447224 -168.384259,
+295.719860 -168.581554,
+295.992496 -168.778859,
+296.265133 -168.976171,
+296.537769 -169.173492,
+296.810405 -169.370821,
+297.083042 -169.568158,
+297.355678 -169.765503,
+297.628314 -169.962856,
+297.900950 -170.160218,
+298.173587 -170.357587,
+298.446223 -170.554965,
+298.718859 -170.752351,
+298.991496 -170.949745,
+299.264132 -171.147147,
+299.536768 -171.344557,
+299.809405 -171.541976,
+300.082041 -171.739402,
+300.354677 -171.936837,
+300.627314 -172.134279,
+300.899950 -172.331730,
+301.172586 -172.529188,
+301.445223 -172.726655,
+301.717859 -172.924129,
+301.990495 -173.121612,
+302.263132 -173.319103,
+302.535768 -173.516601,
+302.808404 -173.714108,
+303.081041 -173.911622,
+303.353677 -174.109145,
+303.626313 -174.306675,
+303.898949 -174.504213,
+304.171586 -174.701759,
+304.444222 -174.899314,
+304.716858 -175.096876,
+304.989495 -175.294445,
+305.262131 -175.492023,
+305.534767 -175.689609,
+305.807404 -175.887202,
+306.080040 -176.084804,
+306.352676 -176.282413,
+306.625313 -176.480030,
+306.897949 -176.677654,
+307.170585 -176.875287,
+307.443222 -177.072927,
+307.715858 -177.270575,
+307.988494 -177.468231,
+308.261131 -177.665895,
+308.533767 -177.863567,
+308.806403 -178.061246,
+309.079040 -178.258933,
+309.351676 -178.456627,
+309.624312 -178.654330,
+309.896948 -178.852040,
+310.169585 -179.049757,
+310.442221 -179.247483,
+310.714857 -179.445216,
+310.987494 -179.642957,
+311.260130 -179.840705,
+311.532766 -180.038461,
+311.805403 -180.236225,
+312.078039 -180.433996,
+312.350675 -180.631775,
+312.623312 -180.829562,
+312.895948 -181.027356,
+313.168584 -181.225157,
+313.441221 -181.422967,
+313.713857 -181.620784,
+313.986493 -181.818608,
+314.259130 -182.016440,
+314.531766 -182.214280,
+314.804402 -182.412127,
+315.077039 -182.609981,
+315.349675 -182.807843,
+315.622311 -183.005713,
+315.894947 -183.203590,
+316.167584 -183.401475,
+316.440220 -183.599367,
+316.712856 -183.797266,
+316.985493 -183.995173,
+317.258129 -184.193088,
+317.530765 -184.391010,
+317.803402 -184.588939,
+318.076038 -184.786876,
+318.348674 -184.984820,
+318.621311 -185.182771,
+318.893947 -185.380730,
+319.166583 -185.578697,
+319.439220 -185.776670,
+319.711856 -185.974651,
+319.984492 -186.172640,
+320.257129 -186.370636,
+320.529765 -186.568639,
+320.802401 -186.766649,
+321.075038 -186.964667,
+321.347674 -187.162692,
+321.620310 -187.360724,
+321.892946 -187.558764,
+322.165583 -187.756811,
+322.438219 -187.954865,
+322.710855 -188.152927,
+322.983492 -188.350996,
+323.256128 -188.549072,
+323.528764 -188.747155,
+323.801401 -188.945246,
+324.074037 -189.143344,
+324.346673 -189.341449,
+324.619310 -189.539561,
+324.891946 -189.737680,
+325.164582 -189.935807,
+325.437219 -190.133941,
+325.709855 -190.332082,
+325.982491 -190.530230,
+326.255128 -190.728385,
+326.527764 -190.926548,
+326.800400 -191.124717,
+327.073037 -191.322894,
+327.345673 -191.521078,
+327.618309 -191.719269,
+327.890945 -191.917467,
+328.163582 -192.115672,
+328.436218 -192.313885,
+328.708854 -192.512104,
+328.981491 -192.710331,
+329.254127 -192.908564,
+329.526763 -193.106805,
+329.799400 -193.305053,
+330.072036 -193.503308,
+330.344672 -193.701570,
+330.617309 -193.899839,
+330.889945 -194.098115,
+331.162581 -194.296399,
+331.435218 -194.494689,
+331.707854 -194.692987,
+331.980490 -194.891292,
+332.253127 -195.089603,
+332.525763 -195.287922,
+332.798399 -195.486248,
+333.071036 -195.684581,
+333.343672 -195.882921,
+333.616308 -196.081268,
+333.888944 -196.279623,
+334.161581 -196.477984,
+334.434217 -196.676353,
+334.706853 -196.874728,
+334.979490 -197.073111,
+335.252126 -197.271500,
+335.524762 -197.469897,
+335.797399 -197.668301,
+336.070035 -197.866712,
+336.342671 -198.065130,
+336.615308 -198.263555,
+336.887944 -198.461987,
+337.160580 -198.660426,
+337.433217 -198.858873,
+337.705853 -199.057326,
+337.978489 -199.255786,
+338.251126 -199.454254,
+338.523762 -199.652728,
+338.796398 -199.851210,
+339.069035 -200.049699,
+339.341671 -200.248194,
+339.614307 -200.446697,
+339.886943 -200.645207,
+340.159580 -200.843724,
+340.432216 -201.042248,
+340.704852 -201.240779,
+340.977489 -201.439317,
+341.250125 -201.637862,
+341.522761 -201.836414,
+341.795398 -202.034974,
+342.068034 -202.233540,
+342.340670 -202.432113,
+342.613307 -202.630694,
+342.885943 -202.829281,
+343.158579 -203.027876,
+343.431216 -203.226477,
+343.703852 -203.425086,
+343.976488 -203.623701,
+344.249125 -203.822324,
+344.521761 -204.020954,
+344.794397 -204.219590,
+345.067034 -204.418234,
+345.339670 -204.616885,
+345.612306 -204.815543,
+345.884942 -205.014208,
+346.157579 -205.212879,
+346.430215 -205.411558,
+346.702851 -205.610244,
+346.975488 -205.808937,
+347.248124 -206.007637,
+347.520760 -206.206344,
+347.793397 -206.405058,
+348.066033 -206.603779,
+348.338669 -206.802508,
+348.611306 -207.001243,
+348.883942 -207.199985,
+349.156578 -207.398734,
+349.429215 -207.597490,
+349.701851 -207.796254,
+349.974487 -207.995024,
+350.247124 -208.193801,
+350.519760 -208.392585,
+350.792396 -208.591377,
+351.065033 -208.790175,
+351.337669 -208.988980,
+351.610305 -209.187792,
+351.882941 -209.386612,
+352.155578 -209.585438,
+352.428214 -209.784272,
+352.700850 -209.983112,
+352.973487 -210.181959,
+353.246123 -210.380814,
+353.518759 -210.579675,
+353.791396 -210.778543,
+354.064032 -210.977419,
+354.336668 -211.176301,
+354.609305 -211.375190,
+354.881941 -211.574087,
+355.154577 -211.772990,
+355.427214 -211.971901,
+355.699850 -212.170818,
+355.972486 -212.369742,
+356.245123 -212.568674,
+356.517759 -212.767612,
+356.790395 -212.966557,
+357.063032 -213.165510,
+357.335668 -213.364469,
+357.608304 -213.563435,
+357.880940 -213.762409,
+358.153577 -213.961389,
+358.426213 -214.160376,
+358.698849 -214.359370,
+358.971486 -214.558372,
+359.244122 -214.757380,
+359.516758 -214.956395,
+359.789395 -215.155417,
+360.062031 -215.354446,
+360.334667 -215.553483,
+360.607304 -215.752526,
+360.879940 -215.951576,
+361.152576 -216.150633,
+361.425213 -216.349697,
+361.697849 -216.548768,
+361.970485 -216.747846,
+362.243122 -216.946931,
+362.515758 -217.146023,
+362.788394 -217.345122,
+363.061031 -217.544228,
+363.333667 -217.743340,
+363.606303 -217.942460,
+363.878939 -218.141587,
+364.151576 -218.340721,
+364.424212 -218.539861,
+364.696848 -218.739009,
+364.969485 -218.938164,
+365.242121 -219.137325,
+365.514757 -219.336493,
+365.787394 -219.535669,
+366.060030 -219.734851,
+366.332666 -219.934040,
+366.605303 -220.133235,
+366.877939 -220.332438,
+367.150575 -220.531647,
+367.423212 -220.730863,
+367.695848 -220.930086,
+367.968484 -221.129316,
+368.241121 -221.328552,
+368.513757 -221.527796,
+368.786393 -221.727045,
+369.059030 -221.926302,
+369.331666 -222.125565,
+369.604302 -222.324835,
+369.876938 -222.524111,
+370.149575 -222.723394,
+370.422211 -222.922684,
+370.694847 -223.121980,
+370.967484 -223.321283,
+371.240120 -223.520593,
+371.512756 -223.719909,
+371.785393 -223.919231,
+372.058029 -224.118560,
+372.330665 -224.317896,
+372.603302 -224.517238,
+372.875938 -224.716586,
+373.148574 -224.915941,
+373.421211 -225.115302,
+373.693847 -225.314670,
+373.966483 -225.514044,
+374.239120 -225.713425,
+374.511756 -225.912812,
+374.784392 -226.112205,
+375.057029 -226.311605,
+375.329665 -226.511011,
+375.602301 -226.710423,
+375.874937 -226.909842,
+376.147574 -227.109267,
+376.420210 -227.308698,
+376.692846 -227.508135,
+376.965483 -227.707579,
+377.238119 -227.907029,
+377.510755 -228.106485,
+377.783392 -228.305948,
+378.056028 -228.505416,
+378.328664 -228.704891,
+378.601301 -228.904372,
+378.873937 -229.103859,
+379.146573 -229.303352,
+379.419210 -229.502851,
+379.691846 -229.702357,
+379.964482 -229.901868,
+380.237119 -230.101386,
+380.509755 -230.300909,
+380.782391 -230.500439,
+381.055028 -230.699975,
+381.327664 -230.899516,
+381.600300 -231.099064,
+381.872936 -231.298618,
+382.145573 -231.498177,
+382.418209 -231.697743,
+382.690845 -231.897314,
+382.963482 -232.096892,
+383.236118 -232.296475,
+383.508754 -232.496065,
+383.781391 -232.695660,
+384.054027 -232.895261,
+384.326663 -233.094868,
+384.599300 -233.294481,
+384.871936 -233.494099,
+385.144572 -233.693724,
+385.417209 -233.893354,
+385.689845 -234.092990,
+385.962481 -234.292632,
+386.235118 -234.492279,
+386.507754 -234.691933,
+386.780390 -234.891592,
+387.053027 -235.091257,
+387.325663 -235.290927,
+387.598299 -235.490603,
+387.870935 -235.690285,
+388.143572 -235.889973,
+388.416208 -236.089666,
+388.688844 -236.289365,
+388.961481 -236.489069,
+389.234117 -236.688779,
+389.506753 -236.888495,
+389.779390 -237.088216,
+390.052026 -237.287943,
+390.324662 -237.487676,
+390.597299 -237.687414,
+390.869935 -237.887157,
+391.142571 -238.086906,
+391.415208 -238.286661,
+391.687844 -238.486421,
+391.960480 -238.686187,
+392.233117 -238.885958,
+392.505753 -239.085734,
+392.778389 -239.285516,
+393.051026 -239.485304,
+393.323662 -239.685096,
+393.596298 -239.884895,
+393.868934 -240.084698,
+394.141571 -240.284507,
+394.414207 -240.484322,
+394.686843 -240.684141,
+394.959480 -240.883966,
+395.232116 -241.083797,
+395.504752 -241.283632,
+395.777389 -241.483473,
+396.050025 -241.683320,
+396.322661 -241.883171,
+396.595298 -242.083028,
+396.867934 -242.282890,
+397.140570 -242.482758,
+397.413207 -242.682630,
+397.685843 -242.882508,
+397.958479 -243.082391,
+398.231116 -243.282279,
+398.503752 -243.482173,
+398.776388 -243.682071,
+399.049025 -243.881975,
+399.321661 -244.081884,
+399.594297 -244.281798,
+399.866933 -244.481717,
+400.139570 -244.681641,
+400.412206 -244.881570,
+400.684842 -245.081505,
+400.957479 -245.281444,
+401.230115 -245.481389,
+401.502751 -245.681338,
+401.775388 -245.881293,
+402.048024 -246.081253,
+402.320660 -246.281217,
+402.593297 -246.481187,
+402.865933 -246.681162,
+403.138569 -246.881141,
+403.411206 -247.081126,
+403.683842 -247.281115,
+403.956478 -247.481110,
+404.229115 -247.681109,
+404.501751 -247.881113,
+404.774387 -248.081122,
+405.047024 -248.281137,
+405.319660 -248.481155,
+405.592296 -248.681179,
+405.864932 -248.881208,
+406.137569 -249.081241,
+406.410205 -249.281280,
+406.682841 -249.481323,
+406.955478 -249.681371,
+407.228114 -249.881424,
+407.500750 -250.081481,
+407.773387 -250.281544,
+408.046023 -250.481611,
+408.318659 -250.681683,
+408.591296 -250.881759,
+408.863932 -251.081840,
+409.136568 -251.281927,
+409.409205 -251.482017,
+409.681841 -251.682113,
+409.954477 -251.882213,
+410.227114 -252.082318,
+410.499750 -252.282427,
+410.772386 -252.482541,
+411.045023 -252.682660,
+411.317659 -252.882783,
+411.590295 -253.082911,
+411.862931 -253.283044,
+412.135568 -253.483181,
+412.408204 -253.683323,
+412.680840 -253.883469,
+412.953477 -254.083620,
+413.226113 -254.283775,
+413.498749 -254.483935,
+413.771386 -254.684099,
+414.044022 -254.884268,
+414.316658 -255.084442,
+414.589295 -255.284620,
+414.861931 -255.484802,
+415.134567 -255.684989,
+415.407204 -255.885181,
+415.679840 -256.085376,
+415.952476 -256.285577,
+416.225113 -256.485781,
+416.497749 -256.685991,
+416.770385 -256.886204,
+417.043022 -257.086422,
+417.315658 -257.286644,
+417.588294 -257.486871,
+417.860930 -257.687102,
+418.133567 -257.887337,
+418.406203 -258.087577,
+418.678839 -258.287821,
+418.951476 -258.488069,
+419.224112 -258.688322,
+419.496748 -258.888579,
+419.769385 -259.088840,
+420.042021 -259.289106,
+420.314657 -259.489375,
+420.587294 -259.689649,
+420.859930 -259.889928,
+421.132566 -260.090210,
+421.405203 -260.290497,
+421.677839 -260.490788,
+421.950475 -260.691083,
+422.223112 -260.891382,
+422.495748 -261.091686,
+422.768384 -261.291994,
+423.041021 -261.492305,
+423.313657 -261.692621,
+423.586293 -261.892942,
+423.858929 -262.093266,
+424.131566 -262.293594,
+424.404202 -262.493927,
+424.676838 -262.694263,
+424.949475 -262.894604,
+425.222111 -263.094949,
+425.494747 -263.295298,
+425.767384 -263.495650,
+426.040020 -263.696007,
+426.312656 -263.896368,
+426.585293 -264.096733,
+426.857929 -264.297102,
+427.130565 -264.497475,
+427.403202 -264.697852,
+427.675838 -264.898233,
+427.948474 -265.098618,
+428.221111 -265.299007,
+428.493747 -265.499400,
+428.766383 -265.699797,
+429.039020 -265.900198,
+429.311656 -266.100602,
+429.584292 -266.301011,
+429.856928 -266.501424,
+430.129565 -266.701840,
+430.402201 -266.902260,
+430.674837 -267.102684,
+430.947474 -267.303113,
+431.220110 -267.503544,
+431.492746 -267.703980,
+431.765383 -267.904420,
+432.038019 -268.104863,
+432.310655 -268.305310,
+432.583292 -268.505762,
+432.855928 -268.706216,
+433.128564 -268.906675,
+433.401201 -269.107137,
+433.673837 -269.307604,
+433.946473 -269.508074,
+434.219110 -269.708547,
+434.491746 -269.909025,
+434.764382 -270.109506,
+435.037019 -270.309991,
+435.309655 -270.510479,
+435.582291 -270.710972,
+435.854927 -270.911468,
+436.127564 -271.111967,
+436.400200 -271.312471,
+436.672836 -271.512978,
+436.945473 -271.713489,
+437.218109 -271.914003,
+437.490745 -272.114521,
+437.763382 -272.315042,
+438.036018 -272.515568,
+438.308654 -272.716097,
+438.581291 -272.916629,
+438.853927 -273.117165,
+439.126563 -273.317705,
+439.399200 -273.518248,
+439.671836 -273.718795,
+439.944472 -273.919345,
+440.217109 -274.119899,
+440.489745 -274.320456,
+440.762381 -274.521017,
+441.035018 -274.721581,
+441.307654 -274.922149,
+441.580290 -275.122721,
+441.852926 -275.323296,
+442.125563 -275.523874,
+442.398199 -275.724456,
+442.670835 -275.925041,
+442.943472 -276.125630,
+443.216108 -276.326222,
+443.488744 -276.526818,
+443.761381 -276.727417,
+444.034017 -276.928019,
+444.306653 -277.128625,
+444.579290 -277.329235,
+444.851926 -277.529847,
+445.124562 -277.730463,
+445.397199 -277.931083,
+445.669835 -278.131706,
+445.942471 -278.332332,
+446.215108 -278.532961,
+446.487744 -278.733594,
+446.760380 -278.934231,
+447.033017 -279.134870,
+447.305653 -279.335513,
+447.578289 -279.536159,
+447.850925 -279.736808,
+448.123562 -279.937461,
+448.396198 -280.138117,
+448.668834 -280.338776,
+448.941471 -280.539439,
+449.214107 -280.740105,
+449.486743 -280.940774,
+449.759380 -281.141446,
+450.032016 -281.342121,
+450.304652 -281.542800,
+450.577289 -281.743482,
+450.849925 -281.944167,
+451.122561 -282.144855,
+451.395198 -282.345547,
+451.667834 -282.546241,
+451.940470 -282.746939,
+452.213107 -282.947640,
+452.485743 -283.148344,
+452.758379 -283.349051,
+453.031016 -283.549762,
+453.303652 -283.750475,
+453.576288 -283.951192,
+453.848924 -284.151911,
+454.121561 -284.352634,
+454.394197 -284.553360,
+454.666833 -284.754089,
+454.939470 -284.954821,
+455.212106 -285.155556,
+455.484742 -285.356294,
+455.757379 -285.557035,
+456.030015 -285.757780,
+456.302651 -285.958527,
+456.575288 -286.159277,
+456.847924 -286.360031,
+457.120560 -286.560787,
+457.393197 -286.761546,
+457.665833 -286.962309,
+457.938469 -287.163074,
+458.211106 -287.363842,
+458.483742 -287.564613,
+458.756378 -287.765388,
+459.029015 -287.966165,
+459.301651 -288.166945,
+459.574287 -288.367728,
+459.846923 -288.568514,
+460.119560 -288.769303,
+460.392196 -288.970095,
+460.664832 -289.170890,
+460.937469 -289.371688,
+461.210105 -289.572489,
+461.482741 -289.773292,
+461.755378 -289.974099,
+462.028014 -290.174908,
+462.300650 -290.375720,
+462.573287 -290.576535,
+462.845923 -290.777353,
+463.118559 -290.978174,
+463.391196 -291.178998,
+463.663832 -291.379824,
+463.936468 -291.580654,
+464.209105 -291.781486,
+464.481741 -291.982321,
+464.754377 -292.183159,
+465.027014 -292.383999,
+465.299650 -292.584843,
+465.572286 -292.785689,
+465.844922 -292.986538,
+466.117559 -293.187390,
+466.390195 -293.388244,
+466.662831 -293.589102,
+466.935468 -293.789962,
+467.208104 -293.990825,
+467.480740 -294.191690,
+467.753377 -294.392559,
+468.026013 -294.593430,
+468.298649 -294.794304,
+468.571286 -294.995180,
+468.843922 -295.196060,
+469.116558 -295.396942,
+469.389195 -295.597826,
+469.661831 -295.798714,
+469.934467 -295.999604,
+470.207104 -296.200497,
+470.479740 -296.401392,
+470.752376 -296.602290,
+471.025013 -296.803191,
+471.297649 -297.004094,
+471.570285 -297.205000,
+471.842921 -297.405909,
+472.115558 -297.606821,
+472.388194 -297.807735,
+472.660830 -298.008651,
+472.933467 -298.209570,
+473.206103 -298.410492,
+473.478739 -298.611417,
+473.751376 -298.812344,
+474.024012 -299.013273,
+474.296648 -299.214206,
+474.569285 -299.415141,
+474.841921 -299.616078,
+475.114557 -299.817018,
+475.387194 -300.017960,
+475.659830 -300.218905,
+475.932466 -300.419853,
+476.205103 -300.620803,
+476.477739 -300.821756,
+476.750375 -301.022711,
+477.023012 -301.223669,
+477.295648 -301.424629,
+477.568284 -301.625592,
+477.840920 -301.826557,
+478.113557 -302.027525,
+478.386193 -302.228495,
+478.658829 -302.429468,
+478.931466 -302.630443,
+479.204102 -302.831421,
+479.476738 -303.032401,
+479.749375 -303.233384,
+480.022011 -303.434369,
+480.294647 -303.635356,
+480.567284 -303.836346,
+480.839920 -304.037339,
+481.112556 -304.238334,
+481.385193 -304.439331,
+481.657829 -304.640331,
+481.930465 -304.841333,
+482.203102 -305.042337,
+482.475738 -305.243344,
+482.748374 -305.444353,
+483.021011 -305.645365,
+483.293647 -305.846379,
+483.566283 -306.047396,
+483.838919 -306.248414,
+484.111556 -306.449436,
+484.384192 -306.650459,
+484.656828 -306.851485,
+484.929465 -307.052513,
+485.202101 -307.253544,
+485.474737 -307.454577,
+485.747374 -307.655612,
+486.020010 -307.856649,
+486.292646 -308.057689,
+486.565283 -308.258731,
+486.837919 -308.459776,
+487.110555 -308.660823,
+487.383192 -308.861872,
+487.655828 -309.062923,
+487.928464 -309.263977,
+488.201101 -309.465033,
+488.473737 -309.666091,
+488.746373 -309.867151,
+489.019010 -310.068214,
+489.291646 -310.269279,
+489.564282 -310.470346,
+489.836918 -310.671415,
+490.109555 -310.872487,
+490.382191 -311.073561,
+490.654827 -311.274637,
+490.927464 -311.475715,
+491.200100 -311.676796,
+491.472736 -311.877878,
+491.745373 -312.078963,
+492.018009 -312.280051,
+492.290645 -312.481140,
+492.563282 -312.682231,
+492.835918 -312.883325,
+493.108554 -313.084421,
+493.381191 -313.285519,
+493.653827 -313.486619,
+493.926463 -313.687721,
+494.199100 -313.888826,
+494.471736 -314.089932,
+494.744372 -314.291041,
+495.017009 -314.492152,
+495.289645 -314.693265,
+495.562281 -314.894380,
+495.834917 -315.095497,
+496.107554 -315.296616,
+496.380190 -315.497738,
+496.652826 -315.698861,
+496.925463 -315.899987,
+497.198099 -316.101115,
+497.470735 -316.302244,
+497.743372 -316.503376,
+498.016008 -316.704510,
+498.288644 -316.905646,
+498.561281 -317.106784,
+498.833917 -317.307924,
+499.106553 -317.509066,
+499.379190 -317.710210,
+499.651826 -317.911357,
+499.924462 -318.112505,
+500.197099 -318.313655,
+500.469735 -318.514807,
+500.742371 -318.715962,
+501.015008 -318.917118,
+501.287644 -319.118276,
+501.560280 -319.319437,
+501.832916 -319.520599,
+502.105553 -319.721763,
+502.378189 -319.922929,
+502.650825 -320.124098,
+502.923462 -320.325268,
+503.196098 -320.526440,
+503.468734 -320.727614,
+503.741371 -320.928790,
+504.014007 -321.129968,
+504.286643 -321.331148,
+504.559280 -321.532330,
+504.831916 -321.733514,
+505.104552 -321.934700,
+505.377189 -322.135887,
+505.649825 -322.337077,
+505.922461 -322.538269,
+506.195098 -322.739462,
+506.467734 -322.940657,
+506.740370 -323.141855,
+507.013007 -323.343054,
+507.285643 -323.544255,
+507.558279 -323.745458,
+507.830915 -323.946662,
+508.103552 -324.147869,
+508.376188 -324.349077,
+508.648824 -324.550288,
+508.921461 -324.751500,
+509.194097 -324.952714,
+509.466733 -325.153930,
+509.739370 -325.355148,
+510.012006 -325.556367,
+510.284642 -325.757589,
+510.557279 -325.958812,
+510.829915 -326.160037,
+511.102551 -326.361264,
+511.375188 -326.562492,
+511.647824 -326.763723,
+511.920460 -326.964955,
+512.193097 -327.166189,
+512.465733 -327.367425,
+512.738369 -327.568663,
+513.011006 -327.769902,
+513.283642 -327.971143,
+513.556278 -328.172386,
+513.828914 -328.373631,
+514.101551 -328.574877,
+514.374187 -328.776126,
+514.646823 -328.977376,
+514.919460 -329.178627,
+515.192096 -329.379881,
+515.464732 -329.581136,
+515.737369 -329.782393,
+516.010005 -329.983651,
+516.282641 -330.184912,
+516.555278 -330.386174,
+516.827914 -330.587438,
+517.100550 -330.788703,
+517.373187 -330.989970,
+517.645823 -331.191239,
+517.918459 -331.392510,
+518.191096 -331.593782,
+518.463732 -331.795056,
+518.736368 -331.996331,
+519.009005 -332.197608,
+519.281641 -332.398887,
+519.554277 -332.600168,
+519.826913 -332.801450,
+520.099550 -333.002734,
+520.372186 -333.204020,
+520.644822 -333.405307,
+520.917459 -333.606595,
+521.190095 -333.807886,
+521.462731 -334.009178,
+521.735368 -334.210472,
+522.008004 -334.411767,
+522.280640 -334.613064,
+522.553277 -334.814362,
+522.825913 -335.015662,
+523.098549 -335.216964,
+523.371186 -335.418267,
+523.643822 -335.619572,
+523.916458 -335.820878,
+524.189095 -336.022186,
+524.461731 -336.223496,
+524.734367 -336.424807,
+525.007004 -336.626120,
+525.279640 -336.827434,
+525.552276 -337.028750,
+525.824912 -337.230067,
+526.097549 -337.431386,
+526.370185 -337.632707,
+526.642821 -337.834029,
+526.915458 -338.035352,
+527.188094 -338.236677,
+527.460730 -338.438004,
+527.733367 -338.639332,
+528.006003 -338.840662,
+528.278639 -339.041993,
+528.551276 -339.243325,
+528.823912 -339.444659,
+529.096548 -339.645995,
+529.369185 -339.847332,
+529.641821 -340.048671,
+529.914457 -340.250011,
+530.187094 -340.451352,
+530.459730 -340.652695,
+530.732366 -340.854040,
+531.005003 -341.055385,
+531.277639 -341.256733,
+531.550275 -341.458082,
+531.822911 -341.659432,
+532.095548 -341.860784,
+532.368184 -342.062137,
+532.640820 -342.263491,
+532.913457 -342.464847,
+533.186093 -342.666205,
+533.458729 -342.867564,
+533.731366 -343.068924,
+534.004002 -343.270286,
+534.276638 -343.471649,
+534.549275 -343.673013,
+534.821911 -343.874379,
+535.094547 -344.075746,
+535.367184 -344.277115,
+535.639820 -344.478485,
+535.912456 -344.679856,
+536.185093 -344.881229,
+536.457729 -345.082603,
+536.730365 -345.283979,
+537.003002 -345.485356,
+537.275638 -345.686734,
+537.548274 -345.888114,
+537.820910 -346.089494,
+538.093547 -346.290877,
+538.366183 -346.492260,
+538.638819 -346.693645,
+538.911456 -346.895032,
+539.184092 -347.096419,
+539.456728 -347.297808,
+539.729365 -347.499199,
+540.002001 -347.700590,
+540.274637 -347.901983,
+540.547274 -348.103377,
+540.819910 -348.304773,
+541.092546 -348.506169,
+541.365183 -348.707568,
+541.637819 -348.908967,
+541.910455 -349.110368,
+542.183092 -349.311769,
+542.455728 -349.513173,
+542.728364 -349.714577,
+543.001001 -349.915983,
+543.273637 -350.117390,
+543.546273 -350.318798,
+543.818909 -350.520208,
+544.091546 -350.721618,
+544.364182 -350.923030,
+544.636818 -351.124444,
+544.909455 -351.325858,
+545.182091 -351.527274,
+545.454727 -351.728691,
+545.727364 -351.930109,
+546.000000 -352.131528)

BI1 0 1l I=I(Ldummy)
RH1 1l 0 1

.END
